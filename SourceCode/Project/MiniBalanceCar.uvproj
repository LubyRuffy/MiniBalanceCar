# Keil uVision project MiniBalanceCar.uvproj, settings and files
target MiniBalanceCar (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MiniBalanceCar +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\Libraries\CMSIS;..\User;..\Libraries\FWlib\inc;..\User\LED;..\User\USART1;..\User\TIMER6;..\User\MOTOR;..\User\ENCODER;..\User\I2C;..\User\MPU6050;..\User\SysTick;..\User\Control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/LED/: LED.c
    ../User/USART1/: USART1.c
    ../User/TIMER6/: TIMER6.c
    ../User/MOTOR/: MOTOR.c
    ../User/ENCODER/: ENCODER.c
    ../User/SysTick/: SysTick.c
    ../User/Control/: Control.c
  group MPU6050
    ../User/I2C/: I2C.c
    ../User/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c
  group DOC
    ../DOC/: Readme.txt
